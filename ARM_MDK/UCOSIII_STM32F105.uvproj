# Keil uVision project UCOSIII_STM32F105.uvproj, settings and files
target UCOSIII_STM32F407 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOSIII_STM32F105 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\BSP;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\STM32_StdPeriph_Library\STM32F4XX_CONF_H;..\STM32_StdPeriph_Library\STM32F4xx_StdPeriph_Driver\inc;..\UCOSIII;..\STM32_StdPeriph_Library\CMSIS\CoreSupport;..\STM32_StdPeriph_Library\CMSIS\DeviceSupport\ST\STM32F4xx;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../STM32_StdPeriph_Library/CMSIS/DeviceSupport/ST/STM32F4xx/startup/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ../STM32_StdPeriph_Library/CMSIS/DeviceSupport/ST/STM32F4xx/: system_stm32f4xx.c
  group uC/CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OSIII_Port
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group uC/OSIII_Source
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_prio.c
  group BSP
    ../BSP/: bsp.c led.c stm32f4xx_it.c
  group Main
    ../Main/: main.c
  group STM32_StdPeriph_Library
    ../STM32_StdPeriph_Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group Readme
    ../Readme/: Readme.txt
